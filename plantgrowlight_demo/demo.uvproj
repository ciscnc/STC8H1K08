# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: demo
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group Src
    ./SRC/: ADC基本操作（中断方式）.c
  group demo
    ./STC8Fxx-Demo_C/: 选择系统时钟源.c 主时钟分频输出.c 主时钟输出切换.c ADC基本操作(查询方式).c ADC中断.c 定时器0（测量脉宽-INT0高电平宽度）.c 定时器1（测量脉宽-INT1高电片宽度）.c
