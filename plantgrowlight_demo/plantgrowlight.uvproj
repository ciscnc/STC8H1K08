# Keil uVision project plantgrowlight.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: plantgrowlight +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc
  group src
    ./Src/: gl08_control.c gl08_hardware.c main.c delay.c uart.c
